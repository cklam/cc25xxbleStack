# IAR project Demo.ewp, settings and files
configuration cB-0950 (8051, debug)
  General.DerivativeDescriptionFile: $TOOLKIT_DIR$\config\devices\Texas Instruments\CC2540F256.i51
  ICC8051.CCDefines: INT_HEAP_LEN=3000; HALNODEBUG; OSAL_CBTIMER_NUM_TASKS=1; HAL_AES_DMA=FALSE; POWER_SAVING; HAL_LCD=FALSE; HAL_LED=FALSE; HAL_KEY=FALSE; CC2540_MINIDK; HAL_UART; HAL_UART_ISR=1; HAL_UART_DMA=0; HAL_UART_ISR_RX_MAX=250; HAL_UART_NO_RTS_CTS; WITHOUT_ESCAPE_SEQUENCE; WITHOUT_BLS_WATCHDOGS
  ICC8051.OCCDataMemoryModel: 1
  ICC8051.OCCCodeMemoryModel: 1
  ICC8051.CCIncludePath2: ..\..\common; ..\..\include; ..\..\..\..\Components\hal\include; ..\..\..\..\Components\hal\target\CC2540EB; ..\..\..\..\Components\hal\target\CC2530EB; ..\..\..\..\Components\hal\target\cB-0950; ..\..\..\..\Components\osal\include; ..\..\..\..\Components\services\saddr; ..\..\..\..\Components\ble\include; ..\..\..\..\Components\ble\controller\phy; ..\..\..\..\Components\ble\controller\include; ..\..\..\..\Components\ble\hci; ..\..\..\..\Components\ble\host; ..\..\common\cc2540; ..\..\Profiles\Roles; ..\..\Profiles\Batt; ..\..\Profiles\HIDDev; ..\..\Profiles\Accelerometer; ..\..\Profiles\DevInfo; ..\..\cbProfiles\Temperature; ..\..\cbProfiles\Led; ..\..\cbProfiles\Serial; ..\..\cB-OLP425Demo\Source; ..\..\..\..\Components\cbhal\include; ..\..\..\..\Components\cbmisc\include
  ICC8051.CCOptLevel: 3
  ICC8051.CCOptStrategy: 1
  ICC8051.IccLang: 0
  XLINK.XclFile: ..\..\common\cc2540\ti_51ew_cc2540b.xcl
  group APP
    ../Source/: cb_assert_handler.c cb_assert_handler.h cb_demo.c cb_demo.h cb_snv_ids.h devinfoservice.c main.c OSAL_init.c
  group cbHAL
    ../../../../Components/cbHal/include/: cb_assert.h cb_hw.h cb_led.h cb_lis3dh.h cb_pio.h cb_swi2c_master.h cb_tmp112.h
    ../../../../Components/cbHal/source/cB-0950/: cb_hw.c cb_led.c cb_lis3dh.c cb_pio.c cb_swi2c_master.c cb_tmp112.c
  group cbMISC
    ../../../../Components/cbMisc/source/: cb_ble_serial.c cb_buffer.c cb_log.c
    ../../../../Components/cbMisc/include/: cb_ble_serial.h cb_buffer.h cb_log.h
  group cbPROFILES
    ../../cbProfiles/Led/: cb_led_service.c cb_led_service.h
    ../../cbProfiles/Serial/: cb_serial_service.c cb_serial_service.h
    ../../cbProfiles/Temperature/: cb_temperature_service.c cb_temperature_service.h
  group HAL/Common
    ../../../../Components/hal/common/: hal_drivers.c
  group HAL/Include
    ../../../../Components/hal/include/: hal_adc.h hal_assert.h hal_board.h hal_defs.h hal_drivers.h hal_flash.h hal_key.h hal_lcd.h hal_led.h hal_rpc.h hal_sleep.h hal_timer.h hal_uart.h
  group HAL/Target/CC2540EB/Config
    ../../../../Components/hal/target/CC2540EB/: hal_board_cfg.h
  group HAL/Target/CC2540EB/Drivers
    ../../../../Components/hal/target/CC2540EB/: hal_adc.c hal_aes.c hal_dma.c hal_flash.c hal_key.c hal_lcd.c hal_led.c hal_sleep.c hal_startup.c hal_timer.c hal_uart.c
  group HAL/Target/CC2540EB/Includes
    ../../../../Components/hal/target/CC2540EB/: hal_aes.h hal_ccm.h hal_dma.h hal_mcu.h hal_types.h
  group LIB
    ../../Libraries/CC2540DB/bin/: CC2540_BLE_peri.lib
    ../../Libraries/Common/bin/: CC254x_BLE_HCI_TL_None.lib
  group OSAL
    ../../../../Components/ble/include/: bcomdef.h
    ../../../../Components/osal/common/: OSAL.c osal_bufmgr.c osal_cbtimer.c OSAL_ClockBLE.c OSAL_Memory.c OSAL_PwrMgr.c OSAL_Timers.c
    ../../../../Components/osal/mcu/cc2540/: osal_snv.c
  group PROFILES
    ../../Profiles/Accelerometer/: accelerometer.c accelerometer.h
    ../../Profiles/Batt/: battservice.c battservice.h
    ../../Profiles/DevInfo/: devinfoservice.h
    ../../Profiles/Roles/: gap.c gapbondmgr.c gapbondmgr.h peripheral.c peripheral.h
    ../../Include/: gapgattserver.h gattservapp.h
    ../../../../Components/ble/host/: gatt_uuid.c
    ../../../../Components/ble/include/: gatt_uuid.h
  group TOOLS
    ../../config/: buildComponents.cfg
    ./: buildConfig.cfg
    ../../common/cc2540/: lnk51ew_cc2530b_banked_rom_data.xcl lnk_banked_rom_data.xcl OnBoard.c OnBoard.h
